/* カーソル移動でマウスレイヤーへ入り、ドラッグスクロールのキーを保持したときだけスクロールする。 */
&trackball {
    automouse-layer = <1>;
    scroll-layers = <8>;
};
